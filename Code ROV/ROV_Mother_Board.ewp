# IAR project ROV_Mother_Board.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: $PROJ_DIR$; Libraries\CMSIS\Include; Libraries\CMSIS\ST\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; Utilities\STM32F4-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ROV_Mother_Board.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  group EWARM
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group Peripheral libraries
    Libraries/STM32F4xx_StdPeriph_Driver/src/: Camera_Control.c CAN_Lib.c Lighting_lib.c measurment_unit.c misc.c Thrusters_lib.c Timing_lib.c
  group STM32 Libraries
    Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ./: system_stm32f4xx.c
  group STM32F4 Discovery
    Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group User Libraries
    Libraries/STM32F4xx_StdPeriph_Driver/src/: communication_lib.c pid_lib.c ROV.c
    ./: main.c stm32f4xx_it.c
